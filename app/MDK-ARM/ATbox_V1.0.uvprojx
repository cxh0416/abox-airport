# Keil uVision project ATbox_V1.0.uvprojx, settings and files
target ATbox_V1.0 (6220000::V6.22::ARMCLANG)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: ATbox_V1_0 +hex
  AfterMake: fromelf.exe --bin --output "#L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Core\User\Inc;..\..\platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x37800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group User
    ../Core/User/Src/: abox_product_port.c app_rc.c bsp_can.c cJSON.c mqtt_app.c mqtt_core.c rc_logic.c rc_protocol.c time_base.c led_message.c motor485.c serial_bus.c app_rc_emout.c app_rc_led.c app_rc_motor.c app_rc_ui.c mqtt_app_cmd.c mqtt_app_hb.c mqtt_core_parser.c mqtt_core_port.c ota_info.c
  group Platform
    ../../platform/src/: abox_platform_config.c abox_platform_port.c
    ../../platform/components/ec_power/: ec_power.c
software components: CMSIS:CORE 6.1.1
